# Keil uVision project STM32F0.uvproj, settings and files
target STM32F0 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\System;..\Main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ../Main/: main.c nmea.c buffer.c mpu6050.c adc.c dma.c
  group Libraries
    ../Libraries/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_dma.c stm32f0xx_adc.c stm32f0xx_rtc.c
  group System
    ../System/: startup_stm32f0xx.s system_stm32f0xx.c stm32f0xx_conf.h stm32f0xx_it.c delay.c i2c.c usart.c timer.c 2401.c
